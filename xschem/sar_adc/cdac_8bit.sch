v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 160 -40 0 0 {name=l1 author="Berkah Saluyu"}
C {ipin.sym} 410 -370 0 0 {name=p2 lab=vref
}
C {iopin.sym} 480 -300 1 0 {name=p3 lab=vss}
C {opin.sym} 550 -370 0 0 {name=p1 lab=vdac}
C {ipin.sym} 410 -330 0 0 {name=p4 lab=dac_in[7:0]

}
C {iopin.sym} 480 -390 3 0 {name=p5 lab=vdd}
