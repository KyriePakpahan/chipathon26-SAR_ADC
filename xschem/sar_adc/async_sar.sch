v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 160 -40 0 0 {name=l1 author="Berkah Saluyu"}
C {ipin.sym} 220 -500 0 0 {name=p1 lab=start}
C {ipin.sym} 220 -460 0 0 {name=p2 lab=out_p}
C {ipin.sym} 220 -420 0 0 {name=p3 lab=out_n
}
C {ipin.sym} 220 -380 0 0 {name=p4 lab=comp_done}
C {opin.sym} 480 -490 0 0 {name=p5 lab=dout[7:0]}
C {iopin.sym} 340 -540 3 0 {name=p6 lab=vdd}
C {iopin.sym} 340 -370 1 0 {name=p7 lab=vss}
C {opin.sym} 480 -420 0 0 {name=p8 lab=sample_en}
C {opin.sym} 480 -390 0 0 {name=p9 lab=rst_latch}
C {opin.sym} 480 -450 0 0 {name=p11 lab=dac_in[7:0]}
C {opin.sym} 480 -360 0 0 {name=p12 lab=done

}
