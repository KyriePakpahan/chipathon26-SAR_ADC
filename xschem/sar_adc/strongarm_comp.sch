v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 160 -40 0 0 {name=l1 author="Berkah Saluyu"}
C {ipin.sym} 260 -420 0 0 {name=p1 lab=vin_p
}
C {ipin.sym} 260 -380 0 0 {name=p2 lab=vin_n
}
C {ipin.sym} 260 -330 0 0 {name=p3 lab=rst_latch


}
C {iopin.sym} 440 -450 3 0 {name=p4 lab=vdd

}
C {iopin.sym} 440 -320 1 0 {name=p5 lab=vss


}
C {opin.sym} 640 -420 0 0 {name=p6 lab=out_p
}
C {opin.sym} 640 -380 0 0 {name=p7 lab=out_n}
C {opin.sym} 640 -340 0 0 {name=p8 lab=comp_done}
