v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 160 -40 0 0 {name=l1 author="Berkah Saluyu"}
C {ipin.sym} 290 -360 0 0 {name=p1 lab=vin}
C {ipin.sym} 290 -320 0 0 {name=p2 lab=sample_en
}
C {opin.sym} 560 -340 0 0 {name=p3 lab=vhold}
C {iopin.sym} 420 -380 3 0 {name=p4 lab=vdd}
C {iopin.sym} 420 -290 1 0 {name=p5 lab=vss}
